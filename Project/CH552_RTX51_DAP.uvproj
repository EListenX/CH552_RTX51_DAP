# Keil uVision project CH552_RTX51_DAP.uvproj, settings and files
target SWD_SPI_SWJ (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x37FF) CLOCK(24000000)
  output: CH552_RTX51_DAP +hex
  AfterMake: python "..\tools\check_firmware_image.py" ".\Objects\SWD_SPI_SWJ\CH552_RTX51_DAP.hex"
  c flags: Optimize=8 SizeSpeed=1
  c define: DAP_SPI_SWD_SWJ=1,DAP_JTAG=1,SWO_UART=0,DAP_SPI_SWD=1,DAP_SPI_SWD_2WIRE=1,PIN_SWCLK_BIT=7,PIN_SWDIO_BIT=6,PIN_TDI_BIT=5,PIN_TDO_PORT=3,PIN_TDO_BIT=3,DAP_HAS_NTRST=1,PIN_nTRST_BIT=2,DAP_HAS_NRESET=1,DAP_PACKET_COUNT=2,DAP_SWD_ASM_WORD=1,DAP_SWD_ASM_ACK=1,DAP_SPI_SWD_GPIO_REQUEST=1,DAP_SPI_SWD_PREFETCH=1,DAP_SWD_FUSED_REQUEST=1,DAP_SWD_FUSED_READ=1,DAP_SWD_SMALL_CORE=1,DAP_SWD_FUSED_PARITY=1,DAP_SWD_ACK_WRITE_TURN=1,DAP_SWD_ACK_WRITE_ONLY=1,DAP_JTAG_GPIO_CORE=1,DAP_JTAG_FAST_CACHE=1,DAP_JTAG_TAP_PATH=1,DAP_JTAG_BIT_CLOCK=1,DAP_JTAG_GPIO_BYTE=1,DAP_JTAG_COMPACT_DISPATCH=1,CDC_EP2_MANUAL_TOG=1,CDC_UART_PRIORITY_FIX=1,CDC_STATE_MASK_FAST=1,CDC_RX_BATCH=1,CDC_RX_FIFO=1,CDC_RX_RING=1,CDC_EP2_XDATA=1,CDC_RX_SNAPSHOT_DIAG=1,CDC_RX_SNAPSHOT_COMPACT=1,CDC_RX_SNAPSHOT_SERVICE=1,CDC_RX_BATCH_MS=2,CDC_RX_RING_SIZE=128,CDC_RX_IDLE_ZLP=1
  c include: ..\Library\include;..\Application\include
  link misc: REMOVEUNUSED
  group App
    ./: STARTUP.A51
    ../Application/: Start.C Usb.C Uart.C DAP.C SW_DP.C JTAG_DP.C SWO.C DAP_SPI.C SWD_Byte.C
  group Lib
    ../Library/: CH55x_Math.A51 Debug.C GPIO.C
  group RTX51 OS
    ./: Conf_tny.A51
target GPIO_SWJ_FULL (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x37FF) CLOCK(24000000)
  output: CH552_RTX51_DAP +hex
  AfterMake: python "..\tools\check_firmware_image.py" ".\Objects\GPIO_SWJ_FULL\CH552_RTX51_DAP.hex"
  c flags: Optimize=8 SizeSpeed=1
  c define: DAP_GPIO_SWJ_SWO=1,DAP_JTAG=1,SWO_UART=1,DAP_HAS_NTRST=1,PIN_SWCLK_BIT=7,PIN_SWDIO_BIT=6,PIN_TDI_BIT=5,PIN_TDO_PORT=3,PIN_TDO_BIT=3,PIN_nTRST_BIT=2,PIN_nRESET_PORT=1,PIN_nRESET_BIT=4,DAP_HAS_NRESET=1,DAP_JTAG_GPIO_CORE=1,DAP_JTAG_FAST_CACHE=1,DAP_JTAG_TAP_PATH=1,DAP_JTAG_BIT_CLOCK=1,DAP_JTAG_GPIO_BYTE=1,CDC_EP2_MANUAL_TOG=1,CDC_UART_PRIORITY_FIX=1,CDC_STATE_MASK_FAST=1,CDC_RX_BATCH=1,CDC_RX_FIFO=1,CDC_RX_RING=1,CDC_EP2_XDATA=1,CDC_RX_SNAPSHOT_DIAG=1,CDC_RX_SNAPSHOT_COMPACT=1,CDC_RX_SNAPSHOT_SERVICE=1,CDC_RX_BATCH_MS=2,CDC_RX_RING_SIZE=128,CDC_RX_IDLE_ZLP=1,DAP_JTAG_COMPACT_DISPATCH=1,DAP_SWD_SMALL_CORE=1
  c include: ..\Library\include;..\Application\include
  link misc: REMOVEUNUSED
target JTAG_SPI_SWJ (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x37FF) CLOCK(24000000)
  output: CH552_RTX51_DAP +hex
  AfterMake: python "..\tools\check_firmware_image.py" ".\Objects\JTAG_SPI_SWJ\CH552_RTX51_DAP.hex"
  c flags: Optimize=8 SizeSpeed=1
  c define: BOARD_IO_PRESET=5,DAP_SPI_DIV=6,DAP_SPI_JTAG_STREAM=1,DAP_SPI_JTAG_WORD=1,DAP_JTAG_FAST_CACHE=1,DAP_JTAG_TAP_PATH=1,DAP_JTAG_BIT_CLOCK=1,CDC_EP2_MANUAL_TOG=1,CDC_UART_PRIORITY_FIX=1,CDC_STATE_MASK_FAST=1,CDC_RX_BATCH=1,CDC_RX_FIFO=1,CDC_RX_RING=1,CDC_EP2_XDATA=1,CDC_RX_SNAPSHOT_DIAG=1,CDC_RX_SNAPSHOT_COMPACT=1,CDC_RX_SNAPSHOT_SERVICE=1,CDC_RX_BATCH_MS=2,CDC_RX_RING_SIZE=128,CDC_RX_IDLE_ZLP=1,DAP_JTAG_COMPACT_DISPATCH=1,DAP_HAS_NRESET=1
  c include: ..\Library\include;..\Application\include
  link misc: REMOVEUNUSED
